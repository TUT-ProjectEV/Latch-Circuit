# Repository TUT-ProjectEV/Latch-Circuit

File README.md:

# Latch-Circuit

## Version
- v1.1

## Overview
- AMS, BSPD, IMDからの信号をモニタ・ラッチしてSDN回路に接続されるリレーをドライブする回路
- AMS, BSPD, IMDのインジケータドライブ回路

## Requirement
### Development
- Kicad 7.0
### Libraries
- ProjectEV-Kicad-Library
    - v7.0

## Usage
- Vsupply: 12V
- AMS, BSPD, IMD Signal Input Level: L=0V, H=12V

## Features
- MOSFETによるラッチング、リレードライブ
- AMS, BSPD, IMD信号入力はMOSFETのゲートであるため、ロジックレベルは3.3V~12Vまで対応可能

## Reference
- ["Reference Site Name"]("Reference URL")

## Author
- [ST04-tkmr](https://github.com/ST04-tkmr)

## License
- Copyright (c) 2024 東京工科大学 ProjectEV

## KiCad design Latch-Circuit/Latch-Circuit.kicad_pcb

Parts:
C1, C4: 0.1u; C_1608M
C2: 10u; C_1608M
C3: 1u; C_2012M
C5, C6, C8, C9, C10: 10n; C_1608M
C7: 22u; C_3216M
C11: 100n; C_1608M
C12: 1n; C_3216M
D1: CUHZ20V,H3F; digikey品番 264-CUHZ20VH3FCT-ND
D2: 1N4448WQ-7-F; digikey品番 1N4448WQ-7-FDICT-ND
D3: PZ1AH11B-AU_R1_000A1; Mouser番号 241-PZ1AH11BAUR1000A
D4, D5, D6, D7: B1911PG--20D000514U1930; digikey品番 3147-B1911PG--20D000514U1930CT-ND
D8, D9, D10: B1911USD-20D000114U1930; digikey品番 3147-B1911USD-20D000114U1930CT-ND
F1: 0ABB-1000-TM; digikey品番 507-0ABB-5000-TMCT-ND
H1, H2, H3, H4: MountingHole_4.3mm_M4_Pad_Via
J1: 2-1445052-2; Mouser番号 571-2-1445052-2
J2: 3-794633-8; Mouser番号 571-3-794633-8
J3: 3-794633-6; Mouser番号 571-3-794633-6
J4: B2P-VH; digikey品番 455-1639-ND
Q1: DMP3098LQ-7; Mouser番号 621-DMP3098LQ-7
Q2, Q3, Q4: 2N7002K-AU_R1_000A2; digikey品番 3757-2N7002K-AU_R1_000A2CT-ND
R1, R6, R13, R15, R17, R25, R26, R27: 100k; R_1608M
R2: 360k; R_1608M
R3, R31, R32, R34: 0; R_1608M
R4, R9, R10, R11, R22, R23, R24: 100; R_1608M
R5, R7, R8, R12, R14, R16, R18, R19, R20, R33, R35, R36: 10k; R_1608M
R21: 1M; R_3216M
R28, R29, R30: 1.2k; R_3216M
U1: TLC555QDRQ1; Mouser番号 595-TLC555QDRQ1
U2: CD4043BPWR; Mouser番号 595-CD4043BPWR
U3: TBD62003AFNG,EL; Mouser番号 757-TBD62003AFNGEL
U4, U5, U6: TLP3106A(TP,F; Mouser番号 757-TLP3106A(TP,F

Connections:
+12V: C3.2, C4.1, C7.1, C11.1, D3.1 (K), Q1.2 (S), R1.2, R2.2, R3.1, R6.1, R8.1, R12.1, R14.1, R16.1, R18.1, R19.1, R20.2, R28.1, R29.1, R30.1, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, U1.4 (~RESET), U1.8 (VDD), U2.5 (EN), U2.16 (VDD), U3.9 (COMMON)
/BMS_LED_A: J3.1, R31.1
/BSPD_LED_A: J3.2, R32.1
/GLV_IN: F1.1, J1.1
/IMD_LED_A: J3.3, R34.1
/RST_SW1: J2.4, R3.2
/RST_SW2: D2.1 (K), J2.8, R4.1
/SHDN_IN: J4.1, U4.6 (Drain)
/SHDN_OUT: J4.2, U6.4 (Drain)
BMS_FAULT: R22.2, U2.2 (Q1)
BMS_LED_K: D8.1 (K), J3.4, U3.15 (O2)
BMS_RLY_OFF: R28.2, U3.16 (O1), U4.1 (Anode)
BMS_STATUS: J2.5, R9.2
BSPD_FAULT: R24.2, U2.10 (Q3)
BSPD_LED_K: D10.1 (K), J3.5, U3.11 (O6)
BSPD_RLY_OFF: R30.2, U3.12 (O5), U6.1 (Anode)
BSPD_STATUS: J2.7, R11.2
Chassis: C12.1, H1.MP (MP_MP), R21.1
GND: C1.1, C2.1, C3.1, C4.2, C5.2, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D1.2 (A), D4.1 (K), J1.2, J1.MP1 (MountPin), J1.MP2 (MountPin), J2.1, J2.3, J2.MP1 (MountPin), J2.MP2 (MountPin), J3.MP1 (MountPin), J3.MP2 (MountPin), Q2.2 (S), Q3.2 (S), Q4.2 (S), R5.2, R7.2, R13.2, R15.2, R17.2, R21.2, R25.1, R26.1, R27.1, U1.1 (GND), U2.1 (Q4), U2.8 (VSS), U2.14 (S4), U2.15 (R4), U3.8 (GND), U4.2 (Cathode), U5.2 (Cathode), U6.2 (Cathode)
IMD_FAULT: R23.2, U2.9 (Q2)
IMD_LED_K: D9.1 (K), J3.6, U3.13 (O4)
IMD_RLY_OFF: R29.2, U3.14 (O3), U5.1 (Anode)
IMD_STATUS: J2.6, R10.2
LampCheck_SIG: D2.2 (A), R6.2, U1.3 (OUT)
unnamed: D1.1 (K), F1.2, Q1.3 (D)
unnamed: D3.2 (A), Q1.1 (G), R5.1
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R12.2
unnamed: D6.2 (A), R14.2
unnamed: D7.2 (A), R16.2
unnamed: D8.2 (A), R33.1
unnamed: D9.2 (A), R35.1
unnamed: D10.2 (A), R36.1
unnamed: C8.1, Q2.1 (G), R9.1, R13.1
unnamed: C9.1, Q3.1 (G), R10.1, R15.1
unnamed: C10.1, Q4.1 (G), R11.1, R17.1
unnamed: C6.2, U1.5 (CONT)
unnamed: C2.2, R2.1, U1.6 (THRES), U1.7 (DISCH)
unnamed: C1.2, R1.1, U1.2 (TRIG)
unnamed: R22.1, R25.2, U3.1 (I1), U3.2 (I2)
unnamed: R23.1, R26.2, U3.3 (I3), U3.4 (I4)
unnamed: R24.1, R27.2, U3.5 (I5), U3.6 (I6)
unnamed: U4.4 (Drain), U5.6 (Drain)
unnamed: U5.4 (Drain), U6.6 (Drain)
RST: C5.1, R4.2, R7.1, U2.3 (R1), U2.7 (R2), U2.11 (R3)
~BMS_STATUS: D5.1 (K), Q2.3 (D), R18.2, U2.4 (S1)
~BSPD_STATUS: D7.1 (K), Q4.3 (D), R20.1, U2.12 (S3)
~IMD_STATUS: D6.1 (K), Q3.3 (D), R19.2, U2.6 (S2)

Notes on the sheet:
ランプチェック回路
点灯時間t = 1.1 × R56 × C31 = 1.1 × 360k × 10u ≈ 3.96 s

Board: 4 copper layers, 64.0 x 54.0 mm, 77 parts (42 on the bottom side), 48 nets.

File Designdocs/bom/bom_Latch-Circuit_20261017.csv:

"ID";"指定子";"フットプリント";"数量";"名称";"供給業者、参考資料";
1;"C1, C4";"C_1608M";2;"0.1u";;;
2;"C2";"C_1608M";1;"10u";;;
3;"C3";"C_2012M";1;"1u";;;
4;"C5, C6, C8, C9, C10";"C_1608M";5;"10n";;;
5;"C7";"C_3216M";1;"22u";;;
6;"C11";"C_1608M";1;"100n";;;
7;"C12";"C_3216M";1;"1n";;;
8;"D1";"CUHZ20V,H3F";1;"CUHZ20V,H3F";;;
9;"D2";"1N4448WQ-7-F";1;"1N4448WQ-7-F";;;
10;"D3";"PZ1AH11B-AU_R1_000A1";1;"PZ1AH11B-AU_R1_000A1";;;
11;"D4, D5, D6, D7";"B1911PG--20D000514U1930";4;"B1911PG--20D000514U1930";;;
12;"D8, D9, D10";"B1911USD-20D000114U1930";3;"B1911USD-20D000114U1930";;;
13;"F1";"0ABB-1000-TM";1;"0ABB-1000-TM";;;
14;"J1";"2-1445052-2";1;"2-1445052-2";;;
15;"J2";"3-794633-8";1;"3-794633-8";;;
16;"J3";"3-794633-6";1;"3-794633-6";;;
17;"J4";"B2P-VH";1;"B2P-VH";;;
18;"Q1";"DMP3098LQ-7";1;"DMP3098LQ-7";;;
19;"Q2, Q3, Q4";"2N7002K-AU_R1_000A2";3;"2N7002K-AU_R1_000A2";;;
20;"R1, R6, R13, R15, R17, R25, R26, R27";"R_1608M";8;"100k";;;
21;"R2";"R_1608M";1;"360k";;;
22;"R3, R31, R32, R34";"R_1608M";4;"0";;;
23;"R4, R9, R10, R11, R22, R23, R24";"R_1608M";7;"100";;;
24;"R5, R7, R8, R12, R14, R16, R18, R19, R20, R33, R35, R36";"R_1608M";12;"10k";;;
25;"R21";"R_3216M";1;"1M";;;
26;"R28, R29, R30";"R_3216M";3;"1.2k";;;
27;"REF**, REF**, REF**, REF**";"MouseBites_5.0mm_OneSide";4;"MouseBites_5.0mm_OneSide";;;
28;"U1";"TLC555QDRQ1";1;"TLC555QDRQ1";;;
29;"U2";"CD4043BPWR";1;"CD4043BPWR";;;
30;"U3";"TBD62003AFNG,EL";1;"TBD62003AFNG,EL";;;
31;"U4, U5, U6";"TLP3106A(TP,F";3;"TLP3106A(TP,F";;;

## Commit log (part)

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2024-03-17 Initialize main
2024-03-17 create project
2024-03-17 add ignore folder
    Latch-Circuit-backups
2024-04-20 add sim file
    シミュレーション済み
2024-04-20 回路図完成、PCBCADに部品追加
2024-04-22 ラベル追加
2024-04-22 若干配置
2024-04-24 コネクタをトップ型に変更、アノテーション、素子配置
2024-04-24 配線完了、リレー配線修正、外周ビア打ち
2024-04-25 完成
    最終チェック後、ガーバー出力
2024-04-25 原点位置の修正
2024-04-26 シャットダウンチェック用のTP追加
2024-04-28 1ピン識別子追加
2024-04-29 コメント追加
2024-05-03 ベタ修正
2024-05-03 ガーバー、BOM出力
2024-05-20 digikey用bom作成
    購入数未入力、他基板素子と同時発注のため
2024-05-20 ファイル名変更
2024-05-23 素子の説明追加
2024-05-23 購入個数追加、csv出力
2024-07-29 modify constant, add NOT for status LED
2024-07-29 modify constant, add circuits Rgs 1M->100k, NOT Circuit for status LED, LED for test
2024-07-29 modify
2024-07-29 re-annotation
2024-07-29 配置、配線終了
2024-07-30 complete AW, DRC next->select parts at JLCPCB
2024-07-30 PCBA用素子選定
2024-07-30 export step
2024-07-30 add 捨て基板, Toolinghole, Fiducial
2024-07-30 generate gerber, production file by JLCPCB Tools
2024-07-30 原点修正
2024-07-30 generate gerber and production files again
2024-08-05 add JLCPCB PCBA BOM
2024-08-12 generate pdf of sch
2024-08-23 README.md を更新
2025-03-23 Format updated to kicad8.0
2025-03-23 Name changed from AMS to BMS
2025-11-08 create a new kicad project
2025-11-08 add title, revision, and date
2025-11-08 add signal labels and power circuit
2025-11-08 complete circuit design, not decide constraints
2025-11-09 modify pin assigns, decide consts, and apply some changes
2025-11-09 ERC done, and modify
2025-11-09 create a new drawio project and add power circuit
2025-11-09 create diagram
2025-11-09 export pdf
2025-11-09 add footprints from sch
2025-11-09 add LEDs
2025-11-09 change relay and led drive circuit
2025-11-09 update relay and led drive circuit
2025-11-09 update footprints, and place components
2025-11-09 finish wiring
2025-11-15 add vias
2025-11-18 add dimension line and DRC OK
2025-11-18 add jlcpcb tools database
2025-12-21 add pcb name
2026-03-30 add breakaway panels and mousebites
2026-03-30 assign lcsc numbers
2026-03-30 generate production files
2026-03-30 toggle BOM
2026-04-04 update bom
2026-04-04 move file
2026-04-04 move a file
2026-04-04 generate bom
2026-04-04 add gerber
2026-04-04 add BOM and CPL for JLCPCB
